SUMMARY = "DOOM"
DESCRIPTION = "Compiles the classic Doom game"
AUTHOR = "bbergan"
LICENSE = ""

SRC_URI = "git://github.com/id-Software/DOOM.git \
		"

do_compile() {

}

do_install() {
	
}